## Kconfig.mcxn947_protocard_mcxn947_cpu0
```kconfig
# SPDX-License-Identifier: Apache-2.0

config BOARD_MCXN947_PROTOCARD
    	select SOC_MCXN947_CPU0
    
```
